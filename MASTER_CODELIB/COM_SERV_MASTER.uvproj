# Keil uVision project COM_SERV_MASTER.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: MASTER +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Master.c KeyScan.c KeyScan.h Delay.c LCD1602.c Delay.h LCD1602.h
